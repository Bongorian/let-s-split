# Repository Bongorian/let-s-split

## KiCad design let-s-Split-v2-master/lets_split/lets_split.kicad_pcb

Board: 2 copper layers, 112.0 x 79.0 mm, 58 parts (3 on the bottom side), 39 nets.

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24: D; Diode_DO-41_SOD81_Horizontal_RM10
J1, J3: 3PIN; jumper
J2: 6PIN; 4pin35mmAudio
R1, R2: R; RESISTOR
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW21, SW22, SW23: SW_PUSH; MXALPS_FLIP
U1: TEENSY_2.0
U2, U3, U4, U5: HOLE
W1: TEST; JUMPER_SMD_2DUB
W2: TEST_1P; SolderWirePad_single_2mmDrill

Connections:
GND: J1.1, J3.1, U1.2, U1.26, U1.27
unnamed: D1.2, SW1.2
unnamed: D2.2, SW2.2
unnamed: D3.2, SW3.2
unnamed: D4.2, SW4.2
unnamed: D5.2, SW5.2
unnamed: D6.2, SW6.2
unnamed: D7.2, SW7.2
unnamed: D8.2, SW8.2
unnamed: D9.2, SW9.2
unnamed: D10.2, SW10.2
unnamed: D11.2, SW11.2
unnamed: D12.2, SW12.2
unnamed: D13.2, SW13.2
unnamed: D14.2, SW14.2
unnamed: D15.2, SW15.2
unnamed: D16.2, SW16.2
unnamed: D17.2, SW17.2
unnamed: D18.2, SW18.2
unnamed: D19.2, SW19.2
unnamed: D21.2, SW21.2
unnamed: D22.2, SW22.2
unnamed: D23.2, SW23.2
unnamed: J1.2, J2.1
unnamed: J2.4, J3.2
unnamed: R1.2, U1.25, W1.2
VCC: J1.3, J3.3, R1.1, R2.2, U1.4
col0: SW1.1, SW2.1, SW3.1, SW4.1, U1.7
col1: SW5.1, SW6.1, SW7.1, SW8.1, U1.8
col2: SW9.1, SW10.1, SW11.1, SW12.1, U1.9
col3: SW13.1, SW14.1, SW15.1, SW16.1, U1.10
col4: SW17.1, SW18.1, SW19.1, U1.11
col5: SW21.1, SW22.1, SW23.1, U1.12
data: J2.2, J2.6, R2.1, U1.24
row0: D1.1, D5.1, D9.1, D13.1, D17.1, D21.1, U1.21
row1: D2.1, D6.1, D10.1, D14.1, D18.1, D22.1, U1.20
row2: D3.1, D7.1, D11.1, D15.1, D19.1, D23.1, U1.19
row3: D4.1, D8.1, D12.1, D16.1, D20.1, D24.1, U1.18
xtradata: J2.3, J2.5, W1.1, W2.1

## Commit log

2017-11-02 init
